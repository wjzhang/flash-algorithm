# Keil uVision project lpc11u35.uvproj, settings and files
target LPC11U35 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: lpc11u35_flash_algo
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c include: ../
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
