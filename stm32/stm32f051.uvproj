# Keil uVision project stm32f051.uvproj, settings and files
target stm32f051 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: stm32f051_flash_algo +hex
  c flags: Optim=1
  scatter file: .\Target.lin
  group Program Functions
    ./common/: FlashPrg.c
  group Device Description
    ./stm32f051/: FlashDev.c
