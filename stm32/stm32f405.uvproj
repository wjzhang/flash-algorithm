# Keil uVision project stm32f405.uvproj, settings and files
target STM32F405 (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: stm32f405_flash_algo
  c flags: Optim=3
  scatter file: .\Target.lin
  group Program Functions
    ./stm32f405/: FlashPrg.c
  group Device Description
    ./stm32f405/: FlashDev.c
