# Keil uVision project stm32f301k8.uvproj, settings and files
target stm32f301k8 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: stm32f301k8_flash_algo +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  scatter file: .\Target.lin
  group Program Functions
    ./common/: FlashPrg.c
  group Device Description
    ./stm32f301k8/: FlashDev.c
