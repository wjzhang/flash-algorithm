# Keil uVision project stm32f103rc.uvproj, settings and files
target STM32F103RC (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32f103rc_flash_algo
  c flags: Optim=3
  scatter file: .\Target.lin
  group Program Functions
    ./common/: FlashPrg.c
  group Device Description
    ./stm32f103rc/: FlashDev.c
