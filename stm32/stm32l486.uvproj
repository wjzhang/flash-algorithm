# Keil uVision project stm32l486.uvproj, settings and files
target STM32L486 (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: stm32l486_flash_algo
  c flags: Optim=3
  scatter file: .\Target.lin
  group Program Functions
    ./stm32l486/: FlashPrg.c
  group Device Description
    ./stm32l486/: FlashDev.c
